<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pubsub_subscriber</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>GooglePubSub_google_subscriber_py_b</key>
<param><key>id</key><value>GooglePubSub_google_subscriber_py_b_0</value></param>
<param><key>google_creds</key><value>/home/christnp/Development/e6889/Google/ELEN-E6889-227a1ecc78b6.json</value></param>
<param><key>project_id</key><value>elen-e6889</value></param>
<param><key>snap_name</key><value>gnuradio-snap</value></param>
<param><key>sub_name</key><value>gnuradio-sub</value></param>
<param><key>topic_name</key><value>gnuradio</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>GooglePubSub_google_subscriber_py_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
